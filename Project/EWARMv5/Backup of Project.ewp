# IAR project Backup of Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; UIP_CONF_IPV6
  ICCARM.CCDiagSuppress: pa050,pe236
  ICCARM.CCIncludePath2: ..\..\Utilities\contiki\core\; ..\..\Utilities\contiki\core\sys\; ..\..\Utilities\contiki\core\net\; ..\..\Utilities\contiki\core\net\mac\; ..\..\Utilities\contiki\core\net\rpl\; ..\..\Utilities\contiki\core\lib; ..\..\Utilities\contiki\core\dev\; ..\..\Libraries\CMSIS\Core\CM3; ..\..\Libraries\STM32_ETH_Driver\inc; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Utilities\uCEVAL_STM32F107; ..\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group contiki/dev
    ../../Utilities/contiki/core/dev/: nullradio.c
  group contiki/lib
    ../../Utilities/contiki/core/lib/: assert.c checkpoint.c crc16.c ifft.c list.c memb.c mmem.c print-stats.c random.c ringbuf.c
  group contiki/net
    ../../Utilities/contiki/core/net/: nbr-table.c netstack.c packetbuf.c packetqueue.c psock.c queuebuf.c rawpacket-udp.c resolv.c sicslowpan.c simple-udp.c slipdev.c tcpdump.c tcpip.c uip-debug.c uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-fw-drv.c uip-fw.c uip-icmp6.c uip-nd6.c uip-neighbor.c uip-over-mesh.c uip-packetqueue.c uip-split.c uip-udp-packet.c uip.c uip6.c uip_arp.c uiplib.c
  group contiki/net/mac
    ../../Utilities/contiki/core/net/mac/: csma.c frame802154.c framer-802154.c framer-nullmac.c mac.c nullrdc.c
  group contiki/net/rime
    ../../Utilities/contiki/core/net/rime/: rimeaddr.c rimestats.c
  group contiki/net/rpl
    ../../Utilities/contiki/core/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-timers.c rpl.c
  group contiki/sys
    ../../Utilities/contiki/core/sys/: arg.c autostart.c ctimer.c energest.c etimer.c process.c procinit.c profile.c rtimer.c stimer.c timer.c
  group ETHLib
    ../../Libraries/STM32_ETH_Driver/src/: stm32_eth.c
  group EWARMv5
    ../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_cl.s
  group FWLib
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group uCEVAL_STM32F107
    ../../Utilities/uCEVAL_STM32F107/: bsp.c
  group User
    ../src/: at89rf231.c clock.c main.c phy-arch.c process_led.c rtimer-arch.c stm32f107.c stm32f10x_it.c watchdog.c
    ../inc/: client.c
